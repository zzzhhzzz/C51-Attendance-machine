# Keil uVision project 指纹密码锁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 指纹密码锁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c KEY.h AT24C02.h LCD12864.h AS608.h T2.H
